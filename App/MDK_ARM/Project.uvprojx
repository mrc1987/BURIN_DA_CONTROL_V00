# Keil uVision project Project.uvprojx, settings and files
target App (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: P1500_APP +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\..\Library\CMSIS;..\..\Library\CMSIS\GD\GD32F30x\Include;..\..\Library\GD32F30x_standard_peripheral\Include;..\..\App;..\User;..\CH395;..\User\Ethernet\W5500;..\User\Ethernet;..\RTT;..\..\RT-Thread\3.1.5\include;..\Driver;..\Driver\LCD
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ../: gd32f30x_it.c main.c systick.c board.c
    ../User/: App_ADC.c App_Init.c App_Task.c App_Lib.c App_UART.c modbus_slave.c
  group CMSIS
    ../../Library/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Peripherals
    ../../Library/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ../../Library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s startup_gd32f30x_cl.s startup_gd32f30x_xd.s
  group Driver
    ../Driver/: bsp_msg.c DRV_UART.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group rtthread
    ../../RT-Thread/3.1.5/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../../RT-Thread/3.1.5/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
